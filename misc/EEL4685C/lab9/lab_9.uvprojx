# Keil uVision project lab_9.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_clock
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c thdDisplay.c thdTick.c Serial.c thdChar.c thdJoystick.c thdSerial.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX5 5.2.3, CMSIS:RTOS2:Keil RTX5 5.5.0, Board Support:Accelerometer 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:Joystick 2.0.0, CMSIS Driver:I2C 2.7, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.1.1, Device:STM32Cube HAL:Cortex 1.1.1, Device:STM32Cube HAL:DMA 1.1.1, Device:STM32Cube HAL:GPIO 1.1.1, Device:STM32Cube HAL:I2C 1.1.1, Device:STM32Cube HAL:RCC 1.1.1, Device:STM32Cube HAL:SRAM 1.1.1, Device:Startup 2.2.1
